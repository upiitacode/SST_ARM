# Keil uVision project example3.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.0.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: example3
  c flags: Optim=1 uC99=1 wLevel=2
  c include: ..\include;..\..\sst\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ../source/: main.c mytask.c sst_user.c interrupts.c boardio.c externalio.c myOtherTask.c
  group sst
    ../../sst/source/: sst.c sst_port.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
